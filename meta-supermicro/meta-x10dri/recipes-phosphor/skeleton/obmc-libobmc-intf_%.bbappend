FILESEXTRAPATHS:prepend:x10dri := "${THISDIR}/${PN}:"
