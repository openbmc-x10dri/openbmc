KBRANCH ?= "dev-6.0"
LINUX_VERSION ?= "6.0.10"

SRCREV="b7b045bf6817c918278fb69d20cdd7e613c98e2a"

require linux-aspeed.inc
